# Keil uVision project PC_Design.uvprojx, settings and files
target PC_Design (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: PC_Design +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --cpp11
  c include: ../Core/Inc;             ../Drivers/STM32F4xx_HAL_Driver/Inc;             ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;             ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;             ../Drivers/CMSIS/Include;             ../Middlewares/Third_Party/FreeRTOS/Source/include;             ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;             ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;             ..\SRML;             ..\USP;             ..\USP\Application;             ..\USP\Drivers;             ..\USP\Middlewares\UpperMonitor;             ..\USP\Middlewares\Game\Gluttonous_Snake;             ..\USP\Middlewares\Game\Tetris;             ..\USP\Drivers\Devices\LCD;             ..\USP\Drivers\Devices\OLED;             ..\USP\Drivers\Devices\PS2;             ..\USP\Drivers\Devices\FLASH;             ..\USP\Drivers\Devices\24CXX;             ..\USP\Drivers\Components\IIC;             ..\USP\Drivers\Components\SPI;             ..\USP\Drivers\Components\DELAY
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/System
    ../USP/Application/: Service_Communication.cpp Service_Debug.cpp Service_Devices.cpp System_Config.cpp System_DataPool.cpp
    ../USP/: srml_config.h
  group Application/User/Drawing
    ../USP/Application/: App_Drawing.c
  group Application/User/Game
    ../USP/Application/: App_Game.cpp App_Interface.cpp
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/UpperMonitor
    ../USP/Middlewares/UpperMonitor/: UpperMonitor.cpp
  group Middlewares/Gmae/Snake
    ../USP/Middlewares/Game/Gluttonous_Snake/: gluttonous_snake.cpp gs_object.cpp
  group Middlewares/Gmae/Tetris
    ../USP/Middlewares/Game/Tetris/: game_map.c object.c process.c
  group Middlewares/LCD/Text
    ../USP/Drivers/Devices/LCD/: text.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_sram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/Components
    ../SRML/Drivers/Components/: drv_timer.c drv_uart.c
    ../USP/Drivers/Components/SPI/: tutu_driver_spi.c
    ../USP/Drivers/Components/IIC/: tutu_drv_i2c.c
  group Drivers/Devices
    ../USP/Drivers/Devices/FLASH/: flash.cpp
    ../USP/Drivers/Devices/OLED/: oled.c
    ../USP/Drivers/Devices/PS2/: ps2.cpp
  group Drivers/Devices/LCD
    ../USP/Drivers/Devices/24CXX/: 24cxx.c
    ../USP/Drivers/Devices/LCD/: touch.c lcd.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
